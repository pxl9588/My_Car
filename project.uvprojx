# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK64FN1M0xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./: main.c servo.c uart.c servo.h uart.h util.h motor.c motor.h PID.c PID.h camera.c camera.h util.c MK64F12.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
